options:
  parameters:
    comment: |-
      DFS tester to verify AP DFS operation
      using HackRF One SDR. 

      Contributions:
       - Adrian Granados (original author)
       - Nigel Bowden

      v0.01 - 31st Dec 2017 - Initial dev build
      v0.02 - 1st Jan 2018 - Added RF gate for on/off function
      v0.03 - 4th Jan 2018 - Rearranged UI widgets and set labels
    generate_options: qt_gui
    id: DFS_Pulse_Tester
    output_language: python
  states: {}

blocks:
- name: Channel_Center_Freq
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      List chooser in GUI to select the channel
      our HackRF will transmit on - NB
    label: Channel
    labels: '["650mhz", "0 | 5180", "36 | 5260", "56 | 5280", "60 | 5300", "64 | 5320", "100 | 5500", "104 | 5520", "108 | 5540", "112 | 5560", "116 | 5580", "120 | 5600", "124 | 5620", "128 | 5640", "132 | 5660", "136 | 5680", "140 | 5700"]'
    num_opts: '0'
    options: '[650000000, 5180000000, 5260000000, 5280000000, 5300000000, 5320000000, 5500000000, 5520000000, 5540000000, 5560000000, 5580000000, 5600000000, 5620000000, 5640000000, 5660000000, 5680000000, 5700000000]'
    type: int
    value: '5260000000'
  states: {}
- name: DFS_Pattern
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      List chooser to select the DFS
      pattern we would like to test - NB
    gui_hint: 0,1
    label: Radar Signature
    labels: '["FCC Type 0", "FCC Type 1", "FCC Type 2", "FCC Type 3", "FCC Type 4", "ETSI Type 1", "ETSI Type 2", "ETSI Type 3", "ETSI Type 4", "ETSI Type 5", "ETSI Type 6"]'
    num_opts: '0'
    options: '[ [1] * 1 * scaler + [0] * 1427 * scaler, [1] * 1 * scaler + [0] * 937 * scaler, [1] * 5 * scaler + [0] * 200 * scaler, [1] * 8 * scaler + [0] * 350 * scaler, [1] * 15 * scaler + [0] * 250 * scaler, [1] * 1 * scaler + [0] * 999 * scaler, [1] * 2 * scaler + [0] * 998 * scaler, [1] * 2 * scaler + [0] * 298 * scaler, [1] * 25 * scaler + [0] * 325 * scaler, [1] * 1 * scaler + [0] * 2499 * scaler, [1] * 1 * scaler + [0] * 832 * scaler ]'
    type: raw
    value: '[1] * 15 * scaler + [0] * 250 * scaler'
  states: {}
- name: Start_Stop
  id: variable_qtgui_chooser
  parameters:
    comment: GUI on/off switch for RF
    label: Pulse
    label0: Stop
    label1: Start
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: raw
    value: '0'
  states: {}
- name: bbgain
  id: variable_qtgui_range
  parameters:
    label: bbgain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: ifgain
  id: variable_qtgui_range
  parameters:
    label: ifgain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '100'
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    label: rfgain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6 * scaler
  states: {}
- name: scaler
  id: variable
  parameters:
    comment: |-
      Scale the sampel rate to better match the "best" frequency for the
      output device

      For example HackRF doesn't work with 1MHz sample rate.
      Everything will be on the wrong frequency when it is not 8MHz
      See https://github.com/adriangranados/dfs-pulse-tester/issues/1
    value: '4'
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: Start_Stop
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: |-
      Added as suggested by 
      messages in warning
      window of GRC - not 
      really sure of its impact,
      but believe it protects
      CPU util - NB
    samples_per_second: '32000'
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: DFS_Pattern
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: bbgain
    bw0: '20000000'
    comment: Sink for SDR (HackRF One)
    freq0: Channel_Center_Freq
    gain0: rfgain
    if_gain0: ifgain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    comment: Visualization of the transmitted signal - NB
    fc: Channel_Center_Freq
    fftsize: '1024'
    plotconst: 'False'
    plotwaterfall: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_multiply_const_xx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_const_xx_0, '0']

metadata:
  file_format: 1
